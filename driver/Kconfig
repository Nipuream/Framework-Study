## driver/Kconfig
```kconfig
config HELLO
       tristate "First Android Driver"
       default y
       help
       This is the first android driver.
```
